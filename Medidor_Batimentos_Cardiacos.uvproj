# Keil uVision project Medidor_Batimentos_Cardiacos.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131A Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: Medidor_Batimentos_Cardiacos
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.a51 lib_lcd.a51 lib_serial.a51 det_pico.a51 lib_adc.a51 controle_ganho.a51
